# Keil uVision project qibeng_software.uvprojx, settings and files
target qibeng_software (ARM-ADS)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: qibeng_software +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx
  c include: ../Core/Inc;../test;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g030xx.s
  group Application/User/Core
    ../Core/Src/: app.c battery.c motor.c ws2812.c power.c main.c gpio.c adc.c dma.c spi.c tim.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Application/User/Test
    ../test/: test_ws2812.c test_motor.c
target qibeng_software_TestWS (ARM-ADS)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: as above
  output: qibeng_software_TestWS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx,TEST_WS2812,WS2812_BRIGHTNESS_PERCENT=100
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
target qibeng_software_TestM (ARM-ADS)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: as above
  output: qibeng_software_TestM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx,TEST_MOTOR
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
target qibeng_software_TestRed (ARM-ADS)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: as above
  output: qibeng_software_TestRed +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx,TEST_WS2812_RED_ONLY,WS2812_BRIGHTNESS_PERCENT=100
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.6.0
